# Keil uVision project Example_UART.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: MG32F02A132 Megawin
  pack: Megawin.CM0_DFP.2.0.4
  cpu: IRAM(0x20000000,0x3800) IRAM2(0x20003800,0x800) IROM(0x00000000,0x21000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Example_UART +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c include: .\UserLib\Inc;.\Main\Inc;.\MGLib\Inc;.\ProjectLib\Inc
  memory RVCT4: ROM 0x0 size 0x21000
  memory RVCT9: RAM 0x20000000 size 0x3800
  memory RVCT10: RAM 0x20003800 size 0x800
software components: CMSIS:CORE 5.4.0, MG32x02z_ChipInit_Wizard:ADC 1.0.0, MG32x02z_ChipInit_Wizard:CSC 1.0.4, MG32x02z_ChipInit_Wizard:EMB 1.0.2, MG32x02z_ChipInit_Wizard:EXIC 1.0.2, MG32x02z_ChipInit_Wizard:GPIO 1.0.2, MG32x02z_ChipInit_Wizard:GPL 1.0.1, MG32x02z_ChipInit_Wizard:IRQ handler 1.0.5, MG32x02z_ChipInit_Wizard:MEM 1.0.1, MG32x02z_ChipInit_Wizard:PW 1.0.1, MG32x02z_ChipInit_Wizard:RST 1.0.1, MG32x02z_ChipInit_Wizard:Timer 1.0.0, MG32x02z_ChipInit_Wizard:URT 1.0.2, MG32x02z_Device:Startup 1.0.3, MG32x02z_Driver:Driver-All 1.0.1, MG32x02z_IRQ_Handler:Systick 1.0.0, MG32x02z_Middleware:Middleware-All 1.0.0
